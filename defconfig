## pf_defconfig
```kconfig
# CONFIG_SCHED_BMQ=y
# CONFIG_AUDIT is not set
# CONFIG_HZ_300 is not set
CONFIG_HZ_1000=y
CONFIG_HZ=1000
CONFIG_SECURITY_TOMOYO=y
CONFIG_RANDOM_TRUST_CPU=y
```
